Commit message: pybullet sim

File: src/sphere.urdf (robot description, URDF)
Before this commit: robot simple_ball, 1 links, 0 joints
Links:
- link ball: mass 1.0 -> 0.0
